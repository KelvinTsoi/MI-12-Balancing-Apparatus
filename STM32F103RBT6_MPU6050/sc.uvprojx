# Keil uVision project sc.uvprojx, settings and files
target MPU6050 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Obj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_STM3210B_EVAL,INTERNAL_PULLUP,USE_FULL_ASSERT
  c include: .\CMSIS\Startup;.\FWlib\inc;.\HARDWARE;.\HARDWARE\eMPL;.\SYSTEM\delay;.\SYSTEM\sys;.\USER;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group HARDWARE
    ./HARDWARE/: i2c.c mpu6050.c usart.c
    ./HARDWARE/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group CMSIS
    ./FWlib/src/: stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_fsmc.c misc.c
  group StartCode
    ./CMSIS/: system_stm32f10x.c
    ./CMSIS/Startup/: startup_stm32f10x_md.s
